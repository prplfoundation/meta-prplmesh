IMAGE_INSTALL_append = " packagegroup-prplmesh"
